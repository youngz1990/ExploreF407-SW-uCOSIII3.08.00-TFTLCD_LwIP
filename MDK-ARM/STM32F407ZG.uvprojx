# Keil uVision project STM32F407ZG.uvprojx, settings and files
target STM32F407ZG (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: STM32F407ZG +hex
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;..\uCOS-III\uC-CPU\ARM-Cortex-M\ARMv7-M\ARM;..\uCOS-III\uC-CPU\Cfg;..\uCOS-III\uC-CPU;..\uCOS-III\uC-LIB\Cfg;..\uCOS-III\uC-LIB;..\uCOS-III\uCOS-III\Cfg;..\uCOS-III\uCOS-III\Ports\ARM-Cortex-M\ARMv7-M\ARM;..\uCOS-III\uCOS-III\Source;..\User\Bsp\Inc;..\User\Inc;..\Lwip-2.1.2;..\Lwip-2.1.2\apps;..\Lwip-2.1.2\include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/User/Core
    ../Core/Src/: main.c stm32f4xx_it.c stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_tim.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_eth.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_ll_fsmc.c stm32f4xx_hal_sram.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group uC-CPU
    ../uCOS-III/uC-CPU/: cpu_core.c
    ../uCOS-III/uC-CPU/ARM-Cortex-M/ARMv7-M/: cpu_c.c
    ../uCOS-III/uC-CPU/BSP/: bsp_cpu.c
    ../uCOS-III/uC-CPU/ARM-Cortex-M/ARMv7-M/ARM/: cpu_a.asm
  group uC-LIB
    ../uCOS-III/uC-LIB/: lib_ascii.c lib_math.c lib_mem.c lib_str.c
  group uCOS-III
    ../uCOS-III/uCOS-III/Cfg/: os_app_hooks.c
    ../uCOS-III/uCOS-III/Ports/ARM-Cortex-M/ARMv7-M/: os_cpu_c.c
    ../uCOS-III/uCOS-III/Ports/ARM-Cortex-M/ARMv7-M/ARM/: os_cpu_a.asm os_cpu_isr.asm
    ../uCOS-III/uCOS-III/Source/: os_cfg_app.c os_core.c os_dbg.c os_flag.c os_mem.c os_msg.c os_mutex.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_var.c
  group User
    ../User/Bsp/Src/: bsp_clk.c bsp_int_armv7m.c bsp_os.c bsp_lcd.c
    ../User/Src/: app.c app_lcd.c app_dbg.c system.c lwip.c
  group LwIP-API
    ../Lwip-2.1.2/api/: api_lib.c api_msg.c err.c if_api.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group LwIP-ARCH
    ../Lwip-2.1.2/arch/: ethernetif.c sys_arch.c
  group LwIP-Core
    ../Lwip-2.1.2/core/: altcp.c altcp_alloc.c altcp_tcp.c def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
    ../Lwip-2.1.2/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
    ../Lwip-2.1.2/core/ipv6/: dhcp6.c ethip6.c icmp6.c inet6.c ip6.c ip6_addr.c ip6_frag.c mld6.c nd6.c
  group LwIP-NetIF
    ../Lwip-2.1.2/netif/: bridgeif.c bridgeif_fdb.c ethernet.c lowpan6.c lowpan6_ble.c lowpan6_common.c slipif.c zepif.c
    ../Lwip-2.1.2/netif/ppp/: auth.c ccp.c chap_ms.c chap-md5.c chap-new.c demand.c eap.c ecp.c eui64.c fsm.c ipcp.c ipv6cp.c lcp.c magic.c mppe.c multilink.c ppp.c pppapi.c pppcrypt.c pppoe.c pppol2tp.c pppos.c upap.c utils.c vj.c
target SRAM (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: as above
  output: STM32F407ZG +hex
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx,VECT_TAB_SRAM
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;..\uCOS-III\uC-CPU\ARM-Cortex-M\ARMv7-M\ARM;..\uCOS-III\uC-CPU\Cfg;..\uCOS-III\uC-CPU;..\uCOS-III\uC-LIB\Cfg;..\uCOS-III\uC-LIB;..\uCOS-III\uCOS-III\Cfg;..\uCOS-III\uCOS-III\Ports\ARM-Cortex-M\ARMv7-M\ARM;..\uCOS-III\uCOS-III\Source;..\User\Bsp\Inc;..\User\Inc;..\Lwip-2.1.2;..\Lwip-2.1.2\apps;..\Lwip-2.1.2\include;..\Lwip-2.1.2\include\lwip;..\Lwip-2.1.2\include\netif
  library: MicroLIB
  memory RVCT4: ROM 0x20000000 size 0xf800
  memory RVCT9: RAM 0x2000f800 size 0xf800
  memory RVCT10: RAM 0x10000000 size 0x10000
software components: CMSIS:CORE 4.3.0
